<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NFM_TX</value></param>
<param><key>author</key><value>Arnaldo Viana</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>INSPER</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Transmissor FM</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>BB_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>62</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>31</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>VGAtx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>47</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>47</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>433e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>466e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>40</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>5</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>samp_rate</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>samp_rate*2</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>F:\BackUpGoogle\Insper\CamadaFisica\CamadaFisica2019\camadaFisicaEnunciadosAPS\9-Modulacao Digital bpks\ArnaldoAM_Tx_Rx\oi2.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>VGAtx_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>5000000</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate * 2</value></param>
<param><key>interp</key><value>2000000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate * 2</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
